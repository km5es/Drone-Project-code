options:
  parameters:
    author: KM
    description: This will go on the drone. A predefined waveform is fed into the companion script which creates a TCP server and loops back into this script. The server also checks for serial toggle and triggers GPIO at set points.
    generate_options: no_gui
    id: gr_cal_tcp_loopback_client
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: gr_cal_tcp_loopback_client
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6*2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '1000'
    minoutbuf: min_buffer
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blks2_tcp_source_0
  id: blks2_tcp_source
  parameters:
    addr: 127.0.0.1
    minoutbuf: min_buffer
    port: '8810'
    server: 'False'
    type: complex
    vlen: min_buffer
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/DA14988F1498706D/Google Drive/UVa/Research/PhD Research/GRC/GRC_1804/qpsk_waveform_transfer
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/DA14988F1498706D/Google Drive/UVa/Research/PhD Research/GRC/GRC_1804/qpsk_waveform_transfer
    repeat: 'True'
    type: complex
    vlen: '1024'
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    minoutbuf: min_buffer
    num_items: min_buffer
    type: complex
  states: {}
- name: device_transport
  id: parameter
  parameters:
    value: str(send_frame_size=8192, num_send_frames=512)
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: 1024*100
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dev_args: '""'
    gain0: '20'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:8810
    minoutbuf: min_buffer
    timeout: '100'
    type: complex
    vlen: min_buffer
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', uhd_usrp_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
