options:
  parameters:
    author: KM
    description: This will go on the drone. A predefined waveform is fed into the companion script which creates a TCP server and loops back into this script. The server also checks for serial toggle and triggers GPIO at set points.
    generate_options: no_gui
    id: gr_cal_tcp_loopback_client
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: gr_cal_tcp_loopback_client
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    comment: Center frequency the SDR will transmit at.
    value: meas_freq - wave_freq
  states: {}
- name: gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: meas_freq
  id: variable
  parameters:
    comment: Center frequency of the measurement on the AUT.
    value: 150e6
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6
  states: {}
- name: wave_freq
  id: variable
  parameters:
    comment: Center frequency of the signal being used by cal_sequence_tcp_server
    value: samp_rate/8
  states: {}
- name: blks2_tcp_source_0
  id: blks2_tcp_source
  parameters:
    addr: 127.0.0.1
    minoutbuf: min_buffer
    port: '8810'
    server: 'False'
    type: complex
    vlen: min_buffer
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8810'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: device_transport
  id: parameter
  parameters:
    label: send_frame_size=8192,  num_send_frames=512
    type: str
    value: send_frame_size=8192,  num_send_frames=512
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_udp_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
