options:
  parameters:
    author: KM
    description: This will go on the drone. A predefined waveform is fed into the companion script which creates a TCP server and loops back into this script. The server also checks for serial toggle and triggers GPIO at set points.
    generate_options: no_gui
    id: gr_cal_tcp_loopback_client
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: gr_cal_tcp_loopback_client
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: 512*8200*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6*2
  states: {}
- name: device_transport
  id: parameter
  parameters:
    value: send_frame_size=8192, num_send_frames=512
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: recv_frame_size=8200, num_recv_frames=2048
    dev_args: '""'
    gain0: '20'
    len_tag_name: ''
    minoutbuf: min_buffer
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:8810
    minoutbuf: min_buffer
    timeout: '10000'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
