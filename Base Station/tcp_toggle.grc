options:
  parameters:
    generate_options: no_gui
    id: tcp_toggle
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: data_buffer
  id: variable
  parameters:
    value: int(4096)
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    comment: Center frequency the SDR will transmit at.
    value: meas_freq - wave_freq
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: meas_freq
  id: variable
  parameters:
    comment: Center frequency of the measurement on the AUT.
    value: 150e6
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: 8200*512
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6/4
  states: {}
- name: wave_freq
  id: variable
  parameters:
    comment: Center frequency of the signal being used by cal_sequence_tcp_server
    value: samp_rate/8
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '8800'
    type: complex
    vlen: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    center_freq0: freq
    center_freq1: freq
    clock_rate: 30.72e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"num_recv_frames=512, recv_frame_size=8200"'
    dev_args: '""'
    gain0: gain
    gain1: '0'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    minoutbuf: min_buffer
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_interleave_0, '0', blocks_tcp_server_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']

metadata:
  file_format: 1
