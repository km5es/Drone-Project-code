options:
  parameters:
    generate_options: no_gui
    id: tcp_toggle
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: data_buffer
  id: variable
  parameters:
    value: int(4096)
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: 512*8200*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6*4
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    maxoutbuf: data_buffer
    minoutbuf: data_buffer
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blks2_tcp_sink_0
  id: blks2_tcp_sink
  parameters:
    addr: 127.0.0.1
    port: '8800'
    server: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {state: disabled}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'False'
    port: '8800'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    maxoutbuf: data_buffer
    minoutbuf: data_buffer
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: 1024*100
    srate: samp_rate
    type: complex
    ymax: '0.01'
    ymin: '-0.01'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: '"num_recv_frames=512, recv_frame_size=8200"'
    dev_args: '""'
    gain0: '20'
    iq_imbal_enb0: '""'
    minoutbuf: min_buffer
    norm_gain0: 'False'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blks2_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', blks2_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_tcp_server_sink_0, '0']

metadata:
  file_format: 1
